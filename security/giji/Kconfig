## security/giji/Kconfig
```kconfig
config SECURITY_GIJI
	bool "giji support"
	depends on SECURITY
	depends on RUST
	default y
```
